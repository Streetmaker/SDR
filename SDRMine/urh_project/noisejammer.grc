options:
  parameters:
    generate_options: qt_gui
    id: noisejammer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cntrfreq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 300e6
    step: .01e6
    stop: 400e6
    value: 315e6
  states: {}
- name: cutfreq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 300e6
    step: .01e3
    stop: 320e6
    value: 315e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: width
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 300e6
    step: 50e3
    stop: 320e6
    value: 315e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '50'
    noise_type: analog.GR_UNIFORM
    seed: '0'
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutfreq
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: width
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    freq0: cntrfreq
    gain0: '0'
    if_gain0: '47'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: cntrfreq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_noise_source_x_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', osmosdr_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
