options:
  parameters:
    generate_options: qt_gui
    id: Radio
    output_language: python
    title: Radio
  states: {}

blocks:
- name: If_Gain_slider
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '8'
    stop: '40'
    value: '24'
  states: {}
- name: Station_preset
  id: variable_qtgui_chooser
  parameters:
    label: Station_preset
    label0: '??'
    num_opts: '4'
    option1: 99.7e6
    option2: 99.9e6
    option3: 88.7e6
    type: real
    value: 104.3e6
    widget: radio_buttons
  states: {}
- name: center_freq_slider
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 88.1e6
    step: 0.1e6
    stop: 108e6
    value: Station_preset
  states: {}
- name: filterOn
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 100e3
    low_cutoff_freq: '-100e3'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 110e3
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '46'
    bw0: 2.75e6 * filterOn
    freq0: center_freq_slider
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: If_Gain_slider
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: int(48e3)
    taps: ''
    type: fff
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [band_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_2, '0']
- [osmosdr_source_0, '0', band_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
