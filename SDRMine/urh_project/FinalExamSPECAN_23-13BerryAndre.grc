options:
  parameters:
    generate_options: qt_gui
    id: SPECAN
    output_language: python
    title: SPECAN
  states: {}

blocks:
- name: centerfreq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 400e6
    step: '100'
    stop: 6e9
    value: 425e6
  states: {}
- name: if_gain_slider
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '8'
    stop: '40'
    value: '24'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '50'
    bw0: '50'
    freq0: centerfreq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: if_gain_slider
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: centerfreq
    fftsize: '8192'
    rate: '20'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
