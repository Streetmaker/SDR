options:
  parameters:
    generate_options: qt_gui
    id: Spectrum_Analyzer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 310e6
    step: .1e6
    stop: 320e6
    value: 315e6
  states: {}
- name: center_freq_slider
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 40e6
    step: 10e3
    stop: 500e6
    value: 107.9e6
  states: {}
- name: if_gain_slider
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '8'
    stop: '40'
    value: '24'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '16'
    bw0: 5e6
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '16'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '8192'
    rate: '20'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
